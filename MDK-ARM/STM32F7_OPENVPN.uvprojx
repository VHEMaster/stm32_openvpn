# Keil uVision project STM32F7_OPENVPN.uvprojx, settings and files
target STM32F7_OPENVPN (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F746BGTx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.10.0
  cpu: IRAM(0x20000000-0x2004FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(12000000) FPU3(SFPU) CPUTYPE("Cortex-M7") ELITTLE
  output: STM32F7_OPENVPN +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 wLevel=2
  c define: MBEDTLS_CONFIG_FILE=<mbedtls_config.h>,USE_HAL_DRIVER,STM32F746xx,ARM_ADS
  c misc: --C99
  c include: ../Inc;../Middlewares/Third_Party/LwIP/src/include;../Middlewares/Third_Party/LwIP/system;../Middlewares/Third_Party/mbedTLS/include;../Drivers/STM32F7xx_HAL_Driver/Inc;../Drivers/STM32F7xx_HAL_Driver/Inc/Legacy;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM7/r0p1;../Middlewares/Third_Party/LwIP/src/include/netif/ppp;../Drivers/CMSIS/Device/ST/STM32F7xx/Include;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;../Middlewares/Third_Party/LwIP/src/include/lwip;../Middlewares/Third_Party/LwIP/src/include/lwip/apps;../Middlewares/Third_Party/LwIP/src/include/lwip/priv;../Middlewares/Third_Party/LwIP/src/include/lwip/prot;../Middlewares/Third_Party/LwIP/src/include/netif;../Middlewares/Third_Party/LwIP/src/include/posix;../Middlewares/Third_Party/LwIP/src/include/posix/sys;../Middlewares/Third_Party/LwIP/system/arch;../Drivers/CMSIS/Include;../mp3/pub; ../Drivers/STM32F7xx_HAL_Driver/Inc/Legacy; ../Middlewares/ST/STM32_USB_Host_Library/Core/Inc; ../Middlewares/ST/STM32_USB_Host_Library/Class/MSC/Inc; ../Middlewares/Third_Party/FatFs/src
  asm include: ..\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0xc0000
  memory RVCT9: RAM 0x20000000 size 0x50000
  link misc: --diag_suppress=L6329
  group Middlewares/mbedTLS
    ../Middlewares/Third_Party/mbedTLS/library/: ssl_cli.c ripemd160.c md.c entropy_poll.c arc4.c entropy.c platform.c havege.c x509write_crt.c aes.c des.c base64.c bignum.c ssl_srv.c sha1.c pkwrite.c certs.c cipher.c timing.c version.c ecdh.c pk_wrap.c pkcs11.c md4.c cmac.c ssl_cookie.c ssl_ticket.c asn1write.c ecdsa.c camellia.c sha512.c hmac_drbg.c ccm.c x509_csr.c threading.c md2.c pkparse.c ecp_curves.c dhm.c debug.c ecjpake.c x509_crt.c blowfish.c aesni.c memory_buffer_alloc.c xtea.c cipher_wrap.c ctr_drbg.c ssl_cache.c pkcs5.c ssl_ciphersuites.c md5.c ssl_tls.c rsa.c version_features.c pkcs12.c asn1parse.c padlock.c x509write_csr.c pem.c error.c x509_create.c pk.c sha256.c x509.c md_wrap.c gcm.c x509_crl.c ecp.c oid.c
  group Middlewares/LwIP
    ../Middlewares/Third_Party/LwIP/src/netif/ppp/: pppapi.c pppcrypt.c eui64.c ipcp.c pppoe.c lcp.c chap-new.c vj.c ipv6cp.c upap.c chap_ms.c multilink.c mppe.c fsm.c chap-md5.c utils.c ccp.c ppp.c demand.c eap.c magic.c ecp.c pppos.c pppol2tp.c auth.c
    ../Middlewares/Third_Party/LwIP/src/core/ipv6/: ip6_frag.c dhcp6.c ip6.c inet6.c ethip6.c mld6.c nd6.c icmp6.c ip6_addr.c
    ../Middlewares/Third_Party/LwIP/src/core/: ip.c pbuf.c dns.c netif.c timeouts.c stats.c mem.c def.c tcp.c sys.c memp.c inet_chksum.c tcp_in.c tcp_out.c udp.c raw.c init.c
    ../Middlewares/Third_Party/LwIP/src/netif/: ethernet.c slipif.c lowpan6.c
    ../Middlewares/Third_Party/LwIP/src/api/: netdb.c api_lib.c netifapi.c api_msg.c tcpip.c sockets.c netbuf.c err.c
    ../Middlewares/Third_Party/LwIP/src/core/ipv4/: ip4.c etharp.c autoip.c ip4_addr.c dhcp.c icmp.c ip4_frag.c igmp.c
    ../Middlewares/Third_Party/LwIP/system/OS/: sys_arch.c
  group MP3
    ../mp3/: mp3dec.c mp3tabs.c
    ../mp3/real/: bitstream.c buffers.c dct32.c dequant.c dqchan.c huffman.c hufftabs.c imdct.c scalfact.c stproc.c subband.c trigtabs.c
    ../mp3/real/arm/: asmpoly.S
  group Drivers/STM32F7xx_HAL_Driver
    ../Drivers/STM32F7xx_HAL_Driver/Src/: stm32f7xx_hal_dma.c stm32f7xx_hal_gpio.c stm32f7xx_hal_i2s.c stm32f7xx_hal_pwr.c stm32f7xx_hal_i2c_ex.c stm32f7xx_hal_eth.c stm32f7xx_hal_dma_ex.c stm32f7xx_hal_tim.c stm32f7xx_hal.c stm32f7xx_hal_tim_ex.c stm32f7xx_hal_rcc_ex.c stm32f7xx_hal_cortex.c stm32f7xx_hal_i2c.c stm32f7xx_hal_rng.c stm32f7xx_hal_flash.c stm32f7xx_hal_rcc.c stm32f7xx_hal_flash_ex.c stm32f7xx_hal_pwr_ex.c stm32f7xx_hal_hcd.c stm32f7xx_ll_usb.c stm32f7xx_hal_sdram.c stm32f7xx_ll_fmc.c
  group Application/MDK-ARM
    ./: startup_stm32f746xx.s
  group Application/User
    ../Src/: stm32f7xx_it.c lwip.c main.c ethernetif.c stm32f7xx_hal_msp.c freertos.c network.c delay.c hardware_rng.c fatfs.c usb_host.c usbh_conf.c usbh_diskio.c random.c openvpn_main.c ethernet_openvpn.c
  group Drivers/CMSIS
    ../Src/: system_stm32f7xx.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: timers.c croutine.c list.c event_groups.c queue.c tasks.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM7/r0p1/: port.c
  group OpenVPN
    ../openvpn/Src/: argv.c base64.c block_dns.c buffer.c clinat.c comp.c compat-basename.c compat-daemon.c compat-dirname.c compat-gettimeofday.c compstub.c console.c console_builtin.c console_systemd.c crypto.c crypto_mbedtls.c cryptoapi.c dhcp.c error.c event.c fdmisc.c forward.c fragment.c gremlin.c helper.c httpdigest.c init.c interval.c list.c lladdr.c manage.c mbuf.c misc.c mroute.c mss.c mstats.c mtcp.c mtu.c mudp.c multi.c ntlm.c occ.c openvpn.c options.c push.c otime.c packet_id.c perf.c pf.c ping.c pkcs11.c pkcs11_mbedtls.c platform.c plugin.c pool.c proto.c proxy.c ps.c reliable.c route.c schedule.c session_id.c shaper.c sig.c socket.c socks.c ssl.c ssl_mbedtls.c ssl_verify.c ssl_verify_mbedtls.c status.c tls_crypt.c tun.c win32.c
  group Middlewares/USB_Host_Library
    ../Middlewares/ST/STM32_USB_Host_Library/Class/MSC/Src/: usbh_msc_bot.c usbh_msc.c usbh_msc_scsi.c
    ../Middlewares/ST/STM32_USB_Host_Library/Core/Src/: usbh_ioreq.c usbh_pipes.c usbh_ctlreq.c usbh_core.c
  group Middlewares/FatFs
    ../Middlewares/Third_Party/FatFs/src/: ff.c ff_gen_drv.c diskio.c
    ../Middlewares/Third_Party/FatFs/src/option/: syscall.c ccsbcs.c
software components: CMSIS:CORE 5.0.1, Compiler:I/O:STDERR 1.2.1, Compiler:I/O:STDIN 1.2.1, Compiler:I/O:STDOUT 1.2.1
